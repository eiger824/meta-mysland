FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# Systemd 
SRC_URI += "file://systemd-additions.cfg"
