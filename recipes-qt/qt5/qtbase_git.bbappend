PACKAGECONFIG_append = " accessibility fontconfig gles2 linuxfb tslib eglfs"
PACKAGECONFIG_remove = " tests examples"
